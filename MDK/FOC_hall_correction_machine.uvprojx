# Keil uVision project FOC_hall_correction_machine.uvprojx, settings and files
target FOC_correction_machine (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: HK32M070K6U7 HK_MicroChip
  pack: HKMicroChip.HK32M07x_DFP.1.0.3
  cpu: IRAM(0x20000000,0x1000) IROM(0x08000000,0x8000) IROM2(0x1fffe800,0x1000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: FOC_hall_correction_machine +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\hwconf;..\applications;..\driver;..\Mcu\HK32M070\Inc;..\motor\MCLib\Any\Inc;..\motor\MCLib\F0xx\Inc;..\motor;..\User;..\Mcu\HK32M070\Driver\HK32M07x_StdPeriphDriver\inc;..\Mcu\HK32M070\Driver\CMSIS\HK32M07x\Include;..\util;..\Mcu\HK32M070\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT5: ROM 0x1fffe800 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group src
    ../User/: main.c mc_config.c mc_parameters.c
  group bsp
    ../driver/: crc.c EEPROM.c flash_helper.c
    ../applications/: app.c app_ppm.c
    ../Mcu/HK32M070/Src/: peripherals.c
    ../util/: utils_math.c
  group motor
    ../motor/: foc_hall.c mc_api.c mc_tasks.c motorcontrol.c
    ../motor/MCLib/Any/Src/: mc_interface.c
  group dev
    ../Mcu/HK32M070/Driver/HK32M07x_StdPeriphDriver/src/: hk32m07x_adc.c hk32m07x_atu.c hk32m07x_flash.c hk32m07x_gpio.c hk32m07x_htu.c hk32m07x_misc.c hk32m07x_pwr.c hk32m07x_uart.c hk32m07x_utu.c hk32m07x_pga.c hk32m07x_rcc.c hk32m07x_syscfg.c hk32m07x_divsqrt.c
    ../motor/MCLib/F0xx/Src/: r3_f0xx_pwm_curr_fdbk.c
    ../motor/MCLib/Any/Src/: circle_limitation.c flux_weakening_ctrl.c mc_math.c pid_regulator.c pwm_curr_fdbk.c ramp_ext_mngr.c revup_ctrl.c speed_pos_fdbk.c speed_torq_ctrl.c state_machine.c virtual_speed_sensor.c
software components: CMSIS:CORE 5.5.0, Device:Startup 1.0.0
