# Keil uVision project FOC_hall_correction_machine_new.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: HK32M070K6U7 HK_MicroChip
  pack: HKMicroChip.HK32M07x_DFP.1.0.3
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(64000000) ELITTLE
  output: FOC_hall_correction_machine +hex
  c define: USE_HAL_DRIVER,HK32M07x,SYSTEM_CORE_CLOCK=64000000
  c include: ../Mcu/HK32M070/Driver/CMSIS/CM0/Core;../Mcu/HK32M070/Driver/CMSIS/HK32M07x/Include;../Mcu/HK32M070/Driver/HK32M07x_StdPeriphDriver/inc;../Mcu/HK32M070/Inc;../User;../hwconf;../motor;../util
  group CMSIS
    ./: 
  group Startup
    ./: 
  group User
    ./:  
  group Hardware
    ./:  
  group Motor
    ./:      
  group Util
    ./: 
  group StdPeriph
    ./:     
