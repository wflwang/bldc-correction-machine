# Keil uVision project FOC_hall_correction_machine_absolute.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: HK32M070K6U7 HK_MicroChip
  pack: HKMicroChip.HK32M07x_DFP.1.0.3
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(64000000) ELITTLE
  output: FOC_hall_correction_machine +hex
  c define: USE_HAL_DRIVER,HK32M07x,SYSTEM_CORE_CLOCK=64000000
  c include: E:\project\ARM\bldc\纠编机\Mcu\HK32M070\Driver\CMSIS\CM0\Core;E:\project\ARM\bldc\纠编机\Mcu\HK32M070\Driver\CMSIS\HK32M07x\Include;E:\project\ARM\bldc\纠编机\Mcu\HK32M070\Driver\HK32M07x_StdPeriphDriver\inc;E:\project\ARM\bldc\纠编机\Mcu\HK32M070\Inc;E:\project\ARM\bldc\纠编机\User;E:\project\ARM\bldc\纠编机\hwconf;E:\project\ARM\bldc\纠编机\motor;E:\project\ARM\bldc\纠编机\util
  group CMSIS
    ./: 
  group Startup
    ./: 
  group User
    ./:  
  group Hardware
    ./:  
  group Motor
    ./:      
  group Util
    ./: 
  group StdPeriph
    ./:     
